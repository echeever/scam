V1 1 0 symbolic
R1 1 2 1000
T1 2 3 4 5 20
R2 4 5 1000
R3 3 0 1000
